Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2018-03-19T10:31:23
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Mar 19 10:31:23 2018 * Host: CHTSP10141 * Database: C:\Users\20062089\AppData\Local\Temp\{A4D9F6D0-E59A-48A3-AEB5-CBA084A18ED9}\ifc * Database version: 5507 * Database creation date: Mon Mar 19 10:31:16 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Mar 19 10:31:16 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Mar 19 10:31:16 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Identity Data - Type Name: 8mm Head; Building Story: yes; Name: Level 1; Structural: no
Graphics - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm

# IfcBuildingElementProxy: Height=7.00m(23'-0")_Reach=4.18m(13'-9"), 1001150411_T12E:Height=7.00m(23'-0")_Reach=4.18m(13'-9"):960380
In: Level 1
Type - Material: JLG_Plastic_Yellow, JLG_Plastic_Green, JLG_Plastic_Blue, JLG_Plastic_Red, JLG_Paint_Black, JLG_Metal Paint_White, JLG_Metal Paint_Black, JLG_Paint_Orange, JLG_Rubber_CYAN, JLG_Plastic_Dark Grey, JLG_Steel, JLG_Paint_Beige, JLG_Rubber_Black, JLG_Plastic_Ligh tGrey
Type - Constraints - AE: 1100 mm; AEa: 0 deg; Height: 6699 mm; Reach: 33
Type - Data - Control system: 12V; Drive speed - lowered: 5.5 kph (3.42 mph); Electrical (pump) motor: 3kW, 48V DC electric motor; Gradeability: 25%; Horizontal Outreach: 4.60 m (15 ft 1 in); Hydraulic system: 21.8 L (5.76 gal); Jib – Overall Length: 3.11 m (10 ft 2 in); Machine weight 2WS (CE): 4,300 kg (9,479.87 lbs); Max Ground Bearing Pressure (CE): 12.5 kg/cm2 (177.79 psi); Model Name: Toucan 12E; Platform Capacity (CE): 200 kg (440 lbs); Platform Height: 9.83 m (32 ft 3 in); Platform Rotator: 120 degree; Platform Size: 0.70 m x 1.05 m (2 ft 4 inx3 ft 5.5 in); Swing: 345° (non continuous); Turning Radius Inside: 0.75m (2 ft 6 in); Turning Radius Outside: 2.60m (8 ft 6.5 in); Tyres (non-marking solid): 457mm dia, 178mm width; Up and Over Height: 6.95 m (22 ft 9 in)
Type - Dimensions - AEa1: 180 deg; PHa: 0 deg; PHa1: 180 deg
Type - General - Platform: 0.70 m x 1.05 m Slide bar rear entry; Platform Rotation (Option): 120 degrees; Tilt Alarm/Indicator Light: 3 degree tilt alarm and indicator light
Type - Identity Data - Manufacturer: JLG; OmniClass Number: 23.40.00.00; OmniClass Title: Equipment and Furnishings; Type Name: Height=7.00m(23'-0")_Reach=4.18m(13'-9")
Type - Model Properties - _Author: n/a; _AuthorizedBy: n/a; _BIMspec_GUID: n/a; _BimSpecGuid: n/a; _BSBibleVersion: n/a; _CreatedBy: JLG; _CurrentRevision: 0; _DistributedBy: JLG; BIMObjectName: 1001150411_Toucan 12E; NBSDescription: Mast boom lifts; NBSNote: n/a; NBSObjectName: JLG_Toucan 12E Mast boom lifts; NBSOfficeMasterTag: n/a; NBSReference: n/a
Type - Other - Category: Mechanical Equipment; AccessibilityPerformance: n/a; AssetIdentifier (default): Please Record On Commissioning; AssetType: Elevators; BarCode (default): Please Record On Commissioning; ClassificationName: n/a; ClassificationValue: n/a; CodePerformance: n/a; Constituents: n/a; CreatedBy: JLG (https://www.jlg.com/en); CreatedOn: 2018; DocumentationCertificates: n/a; DocumentationInstallationGuide: n/a; DocumentationLiterature: n/a; DocumentationMaintenance: n/a; DocumentationTechnical: n/a; DurationUnit: Years; ExpectedLife: n/a; Family Name: 1001150411_T12E; Features: n/a; Finish: n/a; Grade: n/a; InstallationDate (default): n/a; ManufacturerName: JLG (https://www.jlg.com/en); Material: n/a; ModelNumber: Toucan 12E; ModelReference: JLG_Mast boom lifts; ProductionYear: n/a; ReferencedStandard: n/a; ReplacementCost: n/a; SerialNumber (default): Please Record On Commissioning; Shape: n/a; Size: n/a; SpareParts: n/a; TypeName: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Years; WarrantyGuarantorLabor: https://www.jlg.com; WarrantyGuarantorParts: https://www.jlg.com; WarrantyStartDate: Please Record On Commissioning
Pset_BuildingElementProxyCommon - Reference: Height=7.00m(23'-0")_Reach=4.18m(13'-9")
Pset_ManufacturerTypeInformation - ModelReference: JLG_Mast boom lifts; Manufacturer: JLG; ProductionYear: n/a
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 170.939 m2; Platform Rotation: 0 deg; PR: 0 deg; Reach Diagram: no; Sa: 180 deg; Swing_A: 0 deg; Swing_Angle: 0 deg; Turning Radius: no; Volume: 1.18412 m3; Working Area: no
Identity Data - Mark: 41
Other - Family: 1001150411_T12E: Height=7.00m(23'-0")_Reach=4.18m(13'-9"); Family and Type: 1001150411_T12E: Height=7.00m(23'-0")_Reach=4.18m(13'-9"); Type: 1001150411_T12E: Height=7.00m(23'-0")_Reach=4.18m(13'-9"); Type Id: 1001150411_T12E: Height=7.00m(23'-0")_Reach=4.18m(13'-9")
Phasing - Phase Created: Phase 1
